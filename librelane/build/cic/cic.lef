VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO cic
  CLASS BLOCK ;
  FOREIGN cic 0 0 ;
  ORIGIN 0.000 0.000 ;
  SIZE 147.440 BY 95.760 ;
  SYMMETRY X Y ;

  OBS
    LAYER Metal5 ;
      RECT 0.000 0.000 147.440 95.760 ;
  END
END cic

END LIBRARY
